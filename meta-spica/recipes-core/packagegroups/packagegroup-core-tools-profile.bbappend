RRECOMMENDS_packagegroup-core-tools-profile_append_spica = " systemtap"

